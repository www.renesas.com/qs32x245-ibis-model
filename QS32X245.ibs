| I/O Buffer Information Specification (IBIS) Version 3.2 (August 20, 1999)
| IBIS is a standard for electronic behavioral specifications of integrated
| circuit input/output analog characteristics.
[IBIS Ver]   3.2
[File Name]   qs32x245.ibs
[File Rev]   0.0
[Date]   August 31, 2000
[Notes]   IDT provides IBIS models as a service to our customers. You
   and your company shall not distribute, convey, sell or give
   these models to anyone else without receiving prior written
   permission from IDT. IDT reserves the right to make changes to
   its products or to discontinue any semiconductor product or
   service without notice, and advises its customers to obtain
   the latest version of relevant information to verify, before
   placing orders, that the information being relied on is
   current. Please be aware that your receipt and subsequent use
   of the IBIS information provided shall serve as acceptance of
   the terms and conditions of this agreement. If you do not
   accept these terms, you should return the IBIS model and any
   other accompanying information immediately.
[Disclaimer]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
[Copyright]   (C) Copyright 2000 Integrated Device Technology, Inc. All
   rights reserved. Unauthorized reproduction and/or distribution
   is strictly prohibited.
|   Component QS32X245
[Component]   QS32X245
[Manufacturer]   Integrated Device Technology, Inc.
[Package]
| Package parasitics.  Uncomment one set.
| variable   typ   min   max
| SOIC
|[R_pkg]   0.000   0.000   0.000
|[L_pkg]   4.00nH   NA   NA
|[C_pkg]   0.70pF   NA   NA
| QSOP
R_pkg   0.01   0.01   0.01
L_pkg   2.50nH   2.50nH   2.50nH
C_pkg   0.40pF   0.40pF   0.40pF
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
|1   NC   NC   NA   NA   NA
2   A0   NC   NA   NA   NA
3   A1   NC   NA   NA   NA
4   A2   NC   NA   NA   NA
5   A3   NC   NA   NA   NA
6   A4   NC   NA   NA   NA
7   A5   NC   NA   NA   NA
8   A6   NC   NA   NA   NA
9   A7   NC   NA   NA   NA
10   GND   GND   NA   NA   NA
|11   NC   NC   NA   NA   NA
12   A8   NC   NA   NA   NA
13   A9   NC   NA   NA   NA
14   A10   NC   NA   NA   NA
15   A11   NC   NA   NA   NA
16   A12   NC   NA   NA   NA
17   A13   NC   NA   NA   NA
18   A14   NC   NA   NA   NA
19   A15   NC   NA   NA   NA
20   GND   GND   NA   NA   NA
21   B15   NC   NA   NA   NA
22   B14   NC   NA   NA   NA
23   B13   NC   NA   NA   NA
24   B12   NC   NA   NA   NA
25   B11   NC   NA   NA   NA
26   B10   NC   NA   NA   NA
27   B9   NC   NA   NA   NA
28   B8   NC   NA   NA   NA
|29   OE2B   ENABLE   NA   NA   NA
30   vdd   POWER   NA   NA   NA
31   B7   NC   NA   NA   NA
32   B6   NC   NA   NA   NA
33   B5   NC   NA   NA   NA
34   B4   NC   NA   NA   NA
35   B3   NC   NA   NA   NA
36   B2   NC   NA   NA   NA
37   B1   NC   NA   NA   NA
38   B0   NC   NA   NA   NA
|39   OE1B   ENABLE   NA   NA   NA
40   vdd   POWER   NA   NA   NA
[Series Pin Mapping]   pin_2   model_name   function_table_group
2   38   QSIO   1
3   37   QSIO   2
4   36   QSIO   3
5   35   QSIO   4
6   34   QSIO   5
7   33   QSIO   6
8   32   QSIO   7
9   31   QSIO   8
12   28   QSIO   9
13   27   QSIO   10
14   26   QSIO   11
15   25   QSIO   12
16   24   QSIO   13
17   23   QSIO   14
18   22   QSIO   15
19   21   QSIO   16
|   Series_switch   This model type is for series switch
|   devices that can described by [On], [Off],
|   [R Series], [L Series], [Rl Series],
|   [C Series], [Lc Series], [Rc Series],
|   [Series Current] and [Series MOSFET]
|   keywords
[Model]   QSIO
Model_type   Series_switch
| variable   typ   min   max
| Silicon die-compacitance (excluding package cap)
C_comp   4.09pF   3.83pF   4.37pF
[Temperature Range]   25.0   85   -40
[Voltage Range]   5.0V   4.75V   5.25V
[On]
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[Off]
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| Models and submodels in the file (1): QSIO (Series_switch)
